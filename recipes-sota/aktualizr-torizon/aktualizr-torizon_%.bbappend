# Remove bash due to GPLv3
RDEPENDS:${PN}:class-target:remove = "bash"
