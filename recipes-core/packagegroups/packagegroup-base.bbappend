# Remove GPLv3 utilities
RRECOMMENDS:packagegroup-base-vfat:remove = " \
    dosfstools \
"
