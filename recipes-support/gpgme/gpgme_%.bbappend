# Remove the tool due to being GPLv3
RRECOMMENDS:${PN}:remove = "${PN}-tool"
