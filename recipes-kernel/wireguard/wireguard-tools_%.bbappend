# Remove packageconfigs that require bash (GPLv3)
PACKAGECONFIG:remove = "bash-completion wg-quick"
