# Remove readline due to GPLv3. This removes the CLI tool as well.
PACKAGECONFIG:remove = "readline"
